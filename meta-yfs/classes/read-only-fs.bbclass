IMAGE_TEGRAFLASH_FS_TYPE = "squashfs"
IMAGE_FSTYPES:append = " squashfs"