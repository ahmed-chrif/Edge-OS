DESCRIPTION = "Persistent data image"

LICENSE = "MIT"

inherit image

IMAGE_FSTYPES = "ext4"

IMAGE_ROOTFS_SIZE = "1048576"

IMAGE_INSTALL = ""

IMAGE_FEATURES = ""