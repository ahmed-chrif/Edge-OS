SUMMARY = "Confext extension image for edgeos-app configuration"
LICENSE = "MIT"

inherit confext-image
IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""

IMAGE_INSTALL = "edgeos-app-conf"
IMAGE_FSTYPES = "raw"
