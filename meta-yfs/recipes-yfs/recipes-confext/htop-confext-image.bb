SUMMARY = "htop configuration extension image"
LICENSE = "MIT"

inherit confext-image

IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""

IMAGE_INSTALL = "htop-conf"

IMAGE_FSTYPES = "raw"