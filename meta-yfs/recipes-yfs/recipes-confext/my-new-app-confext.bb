SUMMARY = "Configuration confext image for EdgeOS"
LICENSE = "MIT"

inherit confext-image
IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""

IMAGE_INSTALL = "my-new-app-conf"
IMAGE_FSTYPES = "raw"