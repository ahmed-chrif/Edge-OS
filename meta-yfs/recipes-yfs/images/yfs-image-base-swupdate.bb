SWUPDATE_CORE_IMAGE_NAME ?= "yfs-image-base"
require yfs-swupdate-image-common.inc