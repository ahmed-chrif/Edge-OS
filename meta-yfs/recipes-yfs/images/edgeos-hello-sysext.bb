SUMMARY = "Example EdgeOS system extension"

LICENSE = "MIT"

inherit sysext-image

IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""

IMAGE_INSTALL = "htop"

IMAGE_FSTYPES = "raw"