SUMMARY = "Application sysext image for EdgeOS"
LICENSE = "MIT"

inherit sysext-image

IMAGE_FEATURES = ""
IMAGE_LINGUAS = ""

IMAGE_INSTALL = "my-new-app"

IMAGE_FSTYPES = "raw"