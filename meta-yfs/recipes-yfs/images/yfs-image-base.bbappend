IMAGE_FEATURES += "ssh-server-openssh"
IMAGE_INSTALL += "l4t-usb-device-mode"
IMAGE_INSTALL:append = " persistent-mount"